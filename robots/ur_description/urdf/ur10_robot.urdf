Commit message: Fix ur10_robot

File: robots/ur_description/urdf/ur10_robot.urdf (robot description, URDF)
Before this commit: robot ur10, 11 links, 10 joints
Links:
- link base: mass None -> 0.0
- link ee_link: mass None -> 0.0
- link tool0: mass None -> 0.0
